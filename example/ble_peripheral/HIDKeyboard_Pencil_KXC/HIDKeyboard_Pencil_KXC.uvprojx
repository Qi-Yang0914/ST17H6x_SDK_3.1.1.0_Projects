# Keil uVision project HIDKeyboard_Pencil_KXC.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: HIDKeyboard_Pencil_KXC +hex
  AfterMake: fromelf.exe .\Objects\HIDKeyboard_Pencil_KXC.axf --i32combined --output .\bin\HIDKeyboard_Pencil_KXC.hex
  AfterMake: fromelf -c -a -d -e -v -o HIDKeyboard_Pencil_KXC.asm ./Objects/HIDKeyboard_Pencil_KXC.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP  OSAL_CBTIMER_NUM_TASKS=1  MTU_SIZE=247  HOST_CONFIG=4 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0   DEBUG_INFO=0 DBG_ROM_MAIN=0 APP_CFG=0  OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_SLEEP USE_FS=1 MAX_NUM_LL_CONN=1
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08
  c include: ..\..\..\components\inc;..\..\..\components\ble\controller;..\..\..\components\osal\include;..\..\..\components\common;..\..\..\components\ble\include;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\Profiles\ota_app;..\..\..\components\Profiles\DevInfo;..\..\..\components\profiles\HID;..\..\..\components\profiles\ScanParam;..\..\..\components\Profiles\Roles;.\source;..\..\..\components\libraries\crc16;..\..\..\components\libraries\fs;..\..\..\components\driver\clock;..\..\..\components\arch\cm0;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\gpio;..\..\..\components\driver\timer;..\..\..\misc;..\..\..\components\driver\log;..\..\..\components\libraries\cliface;..\..\..\components\driver\key;..\..\..\components\driver\pwm;..\..\..\components\driver\flash;.\Source;..\..\..\components\driver\adc;.\Source\Batt;.\Source\DevInfo;.\Source\HID;.\Source\User;.\Source\Roles
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./: main.c
  group driver
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/timer/: timer.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/key/: key.c
    ../../../components/driver/pwm/: pwm.c
    ../../../components/libraries/fs/: fs.c
    ../../../components/osal/snv/: osal_snv.c
    ../../../components/driver/flash/: flash.c
    ../../../components/driver/adc/: adc.c
  group profile
    ../../../components/profiles/Roles/: central.c gap.c gapgattserver.c peripheral.c
    ./Source/Roles/: gapbondmgr.c
    ../../../components/profiles/GATT/: gattservapp.c
    ../../../components/profiles/ota_app/: ota_app_service.c
    ./Source/DevInfo/: devinfoservice.c
    ./Source/Batt/: battservice.c
  group jump
    ../../../misc/: jump_table.c
  group lib
    ../../../lib/: rf.lib ble_host.lib
  group app
    ./source/: hidkbd.c hidkbd_Main.c OSAL_hidkbd.c
    ./Source/HID/: hiddev.c hidkbdservice.c
    ./Source/User/: LC_Common.c LC_Common.h LC_ADC.c LC_Event_Handler.c LC_Key.c LC_UI_led_buzzer.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
